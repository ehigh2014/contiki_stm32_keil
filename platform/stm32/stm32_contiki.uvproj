# Keil uVision project stm32_contiki.uvproj, settings and files
target Contiki_stm32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_contiki
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,WITH_LED_BLINK,WITH_CONTIKI_SHELL
  c include: .;..\..\core\cfs;..\..\core\ctk\libconio;..\..\core\ctk;..\..\core\dev;..\..\core\lib\strncasecmp;..\..\core\lib;..\..\core\loader;..\..\core\net;..\..\core\net\mac;..\..\core\net\rpl;..\..\core\net\mac\contikimac;..\..\cpu\arm\stm32f103;..\..\core\sys;..\..\core;..\..\cpu\arm\stm32f103\STM32F10x_StdPeriph_Driver\inc;..\..\cpu\arm\common;..\stm32;..\..\apps\shell;..\..\apps\serial-shell;.\dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c rtimer.c stimer.c timer.c
    ../../core/net/: linkaddr.c nbr-table.c packetbuf.c queuebuf.c
    ../../core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c settings.c trickle-timer.c
    ../../core/dev/: serial-line.c
  group cpu
    ../../cpu/arm/stm32f103/: clock.c debug-uart.c mtarch.c rtimer-arch.c
    ../../cpu/arm/stm32f103/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group examples
    ../../examples/stm32f10x/: led_blink.c stm32_shell.c shell_blink.c
  group platform
    ./: contiki-main.c stm32f10x_it.c
    ./dev/: uart1.c
  group apps
    ../../apps/serial-shell/: serial-shell.c
    ../../apps/shell/: shell.c shell-run.c
  group CMSIS
    ../../cpu/arm/stm32f103/: core_cm3.c system_stm32f10x.c
  group MDK-ARM
    ../../cpu/arm/stm32f103/startup/MDK-ARM/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
